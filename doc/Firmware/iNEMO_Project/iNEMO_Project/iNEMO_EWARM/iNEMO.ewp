# IAR project iNEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32F10X_HD; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: .; ..\..\FreeRTOS\Source\include\; ..\iNemo_Task\; ..\virtual_com\inc; ..\utils\inc; ..\iNEMO_Lib\LSM303DLH\inc; ..\iNEMO_Lib\iNEMO_Config\inc; ..\iNEMO_Lib\LPRYxxxAL\inc; ..\iNEMO_Lib\LPS001Dl\inc; ..\iNEMO_Lib\STLM75\inc; ..\iNEMO_Lib\AHRS\inc; ..\iNEMO_Lib\sdiolibrary\inc; ..\iNEMO_Lib\push_button\inc; ..\iNEMO_Lib\user_led\inc; ..\iNEMO_Lib\AHRS Library\inc; ..\iNEMO_GUI_Layer\inc\; ..\..\..\Common\STM32F10xFWLib\v3_3_0\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\Common\STM32F10xFWLib\v3_3_0\Libraries\CMSIS\CM3\CoreSupport\; ..\..\..\Common\STM32F10xFWLib\v3_3_0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\..\..\Common\STM32_USB-FS-Device_Lib\v3_2_1\Libraries\STM32_USB-FS-Device_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: iNEMO.hex
  ILINK.IlinkOutputFile: iNEMO.out
  ILINK.IlinkIcfFile: stm32f10x_flash_offset.icf
  ILINK.IlinkAdditionalLibs: ..\iNEMO_Lib\AHRS Library\inc\iNEMO_AHRS.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group application
    ../iNemo_Task/: iNemo.c iNemo.h test.c
    ./: main.c stm32f10x_it.c
    ../utils/src/: utils.c
  group CMSIS
    ../../../Common/STM32F10xFWLib/v3_3_0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Common/STM32F10xFWLib/v3_3_0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARMv5
    ../../../Startup_Files/iar_FreeRTOS/: startup_stm32f10x_hd.s
  group FreeRTOS files
    ./: FreeRTOSConfig.h
    ../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOS/Source/: list.c queue.c tasks.c
    ../../FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group iNEMO GUI Layer
    ../iNEMO_GUI_Layer/src/: GUI_Layer.c
    ../iNEMO_GUI_Layer/inc/: GUI_Layer.h
  group iNEMO Library/AHRS Library
    ../iNEMO_Lib/AHRS Library/src/: iNEMO_AHRS_MemMan_2.c
  group iNEMO Library/iNEMO_Config
    ../iNEMO_Lib/iNEMO_Config/inc/: iNEMO_conf.h iNEMO_lib.h
    ../iNEMO_Lib/iNEMO_Config/src/: iNEMO_lib.c
  group iNEMO Library/LPRYxxxAL
    ../iNEMO_Lib/LPRYxxxAL/inc/: HAL_LPRYxxxAL.h LPRYxxxAL.h
    ../iNEMO_Lib/LPRYxxxAL/src/: LPRYxxxAL.c
  group iNEMO Library/LPS001DL
    ../iNEMO_Lib/LPS001DL/inc/: HAL_LPS001DL.h LPS001DL_I2C.h
    ../iNEMO_Lib/LPS001DL/src/: LPS001DL_I2C.c
  group iNEMO Library/LSM303DLH
    ../iNEMO_Lib/LSM303DLH/inc/: HAL_LSM303DLH.h LSM303DLH.h
    ../iNEMO_Lib/LSM303DLH/src/: LSM303DLH.c
  group iNEMO Library/Push_Button
    ../iNEMO_Lib/push_button/src/: iNEMO_button.c
    ../iNEMO_Lib/push_button/inc/: iNEMO_Button.h
  group iNEMO Library/SDIO_Library
    ../iNEMO_Lib/sdiolibrary/src/: sdcard.c
    ../iNEMO_Lib/sdiolibrary/inc/: sdcard.h
  group iNEMO Library/STLM75
    ../iNEMO_Lib/STLM75/inc/: HAL_STLM75.h STLM75.h
    ../iNEMO_Lib/STLM75/src/: STLM75.c
  group iNEMO Library/User_Led
    ../iNEMO_Lib/user_led/src/: iNEMO_led.c
    ../iNEMO_Lib/user_led/inc/: iNEMO_Led.h
  group ST Library/v3_3_0
    ../../../Common/STM32F10xFWLib/v3_3_0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group USB Library/v3_2_1
    ../../../Common/STM32_USB-FS-Device_Lib/v3_2_1/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Virtual COM Library
    ../virtual_com/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c virtual_com.c
